IMAGE_INSTALL += " \
	bluez5 \
	links \
	"

require ../../conf/machine/include/edison-image-config.inc
